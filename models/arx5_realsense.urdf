Commit message: Update python examples and fix data error protection

File: models/arx5_realsense.urdf (robot description, URDF)
Before this commit: robot arx5_gopro, 8 links, 7 joints
Joints:
- joint gripper_fixed_joint: origin xyz=0.225 0.0 0.0 rpy=0 0 0 -> xyz=0.03 0.0 0.0 rpy=0 0 0
